options:
  parameters:
    generate_options: no_gui
    id: receiver_flowgraph
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: 0e6
    dc_offs_enb0: 'True'
    dev_addr: addr=192.168.10.2
    gain0: rx_gain
    iq_imbal_enb0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/received_samples.dat
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
