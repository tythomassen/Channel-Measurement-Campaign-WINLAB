options:
  parameters:
    generate_options: qt_gui
    id: receiver_flowgraph
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 400e6
    step: 1e6
    stop: 4400e6
    value: 900e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: 0e6
    dev_addr: addr=192.168.10.2
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
